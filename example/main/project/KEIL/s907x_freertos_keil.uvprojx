# Keil uVision project s907x_freertos_keil.uvprojx, settings and files
target s907x_freertos (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: application +hex
  AfterMake: fromelf --text -s -v $P\..\..\..\..\out\KEIL\Debug\Exe\application.axf
  AfterMake: CSCRIPT "$P\..\..\..\..\script\links\KEIL\s9070_build.vbs" "$P\..\..\..\..\out\KEIL\Debug" "$P..\..\..\..\out\KEIL"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: S9070
  c include: ..\..\..\..\code\atcmd;..\..\..\..\code\atcmd\at_esp;..\..\..\..\code\atcmd\at_test;..\..\..\..\code\cmsis;..\..\..\..\code\cmsis\inc;..\..\..\..\code\core\hal;..\..\..\..\code\core\wlan;..\..\..\..\code\core\os;..\..\..\..\code\core\os\freertos_v10.0.1\Source\include;..\..\..\..\code\core\os\freertos_v10.0.1\Source\portable\RVDS\ARM_CM4F;..\..\..\..\code\net;..\..\..\..\code\net\httpc;..\..\..\..\code\net\dhcps;..\..\..\..\code\net\ping;..\..\..\..\code\net\lwip\lwip_v1.4.1\port\sci;..\..\..\..\code\net\lwip\lwip_v1.4.1\src\include\ipv4;..\..\..\..\code\net\lwip\lwip_v1.4.1\src\include\ipv6;..\..\..\..\code\net\lwip\lwip_v1.4.1\src\apps\sntp;..\..\..\..\code\net\lwip\lwip_v1.4.1\port\sci\freertos;..\..\..\..\code\net\lwip\lwip_v1.4.1\src\include;..\..\..\..\code\net\lwip\lwip_v1.4.1\src\include\posix;..\..\..\..\code\net\mbedtls\include;..\..\..\..\code\utils;..\..\..\..\code\system;..\..\..\..\code\net\mqtt\MQTTPacket\src;..\..\..\..\code\net\mqtt\MQTTPacket\samples;..\..\..\..\code\utils\cJSON;..\..\..\..\code\fs\kv;..\..\..\..\code\fs\kv\include
  memory RVCT4: ROM 0x18060000 size 0x50000
  memory RVCT9: RAM 0x10015900 size 0x50000
  scatter file: ..\..\..\..\script\links\KEIL\s90x_exec.sct
  link misc: ..\..\..\..\script\links\KEIL\s907x_bin_api.c
  group cmsis
    ../../../../code/cmsis/: s907x_cortex.c
  group at
    ../../../../code/atcmd/: at_cmd.c
  group at/at_esp
    ../../../../code/atcmd/at_esp/: at_network.c at_wlan.c at_esp_init.c
  group at/at_test
    ../../../../code/atcmd/at_test/: adc_test.c at_test.c flash_test.c gpio_test.c i2c_test.c i2s_test.c ping_test.c rtc_test.c spi_test.c timer_test.c uart_test.c wdg_test.c wlan_test.c tuya_test.c mqtt_test.c iperf_test.c ipref_sockets.c ota_test.c kv_test.c
  group libs
    ../../../../library/keil/: s907x_net.lib s907x_platform.lib
  group core/hal
    ../../../../code/core/hal/: hal.h hal_adc.h hal_clk.h hal_config.h hal_def.h hal_dma.h hal_flash.h hal_gpio.h hal_i2c.h hal_i2s.h hal_interrupt.h hal_loguart.h hal_pinmux.h hal_rcc.h hal_rtc.h hal_sleep.h hal_spi.h hal_timer.h hal_uart.h hal_wdg.h
  group core/os
    ../../../../code/core/os/: freertos_callback.c
  group core/os/freertos
    ../../../../code/core/os/freertos_v10.0.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group core/os/freertos/mem
    ../../../../code/core/os/freertos_v10.0.1/Source/portable/MemMang/: heap_4.c
  group core/os/freertos/portable
    ../../../../code/core/os/freertos_v10.0.1/Source/portable/RVDS/ARM_CM4F/: port.c
  group core/wlan
    ../../../../code/core/wlan/: wlan_api.h
  group fs/kv
    ../../../../code/fs/kv/: kv.c kv_adapt.c kv_cli.c kv_secure.c
  group network/dhcpc
    ../../../../code/net/dhcpc/: dhcpc.c
  group network/dhcps
    ../../../../code/net/dhcps/: dhcps.c
  group network/lwip1.4.1/api
    ../../../../code/net/lwip/lwip_v1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip1.4.1/app/sntp
    ../../../../code/net/lwip/lwip_v1.4.1/src/apps/sntp/: sntp.c sntp_api.c sntp_time.c
  group network/lwip1.4.1/app/http
    ../../../../code/net/lwip/lwip_v1.4.1/src/apps/httpd/: httpd.c
  group network/lwip1.4.1/app/lwipf
    ../../../../code/net/lwip/lwip_v1.4.1/src/apps/lwiperf/: sci_lwiperf.c
  group network/lwip1.4.1/core
    ../../../../code/net/lwip/lwip_v1.4.1/src/core/: netif.c def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group network/lwip1.4.1/core/ipv4
    ../../../../code/net/lwip/lwip_v1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group network/lwip1.4.1/core/ipv6
    ../../../../code/net/lwip/lwip_v1.4.1/src/core/ipv6/: icmp6.c inet6.c ip6.c ip6_addr.c
  group network/lwip1.4.1/core/snmp
    ../../../../code/net/lwip/lwip_v1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group network/lwip1.4.1/netif
    ../../../../code/net/lwip/lwip_v1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group network/lwip1.4.1/netif/ppp
    ../../../../code/net/lwip/lwip_v1.4.1/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c lwip_md5.c magic.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group network/lwip1.4.1/port
    ../../../../code/net/lwip/lwip_v1.4.1/port/sci/freertos/: sys_arch.c
  group network/http
    ../../../../code/net/httpc/: httpc_api.c httpc_core.c
  group network/mbedtls
    ../../../../code/net/mbedtls/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c hmac_drbg.c
  group network/ping
    ../../../../code/net/ping/: ping.c
  group network/mqtt/MQTTPacket
    ../../../../code/net/mqtt/MQTTPacket/src/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c
  group network/mqtt/MQTTtransport
    ../../../../code/net/mqtt/MQTTPacket/samples/: transport.c
  group startup
    ../../../../code/startup/: system_start.c
  group utils
    ../../../../code/utils/: ota_hash.c ota_md5.c utils.c
  group utils/smartlink
    ../../../../code/utils/: smartlink.c
  group scripts
    ../../../../script/links/KEIL/: s90x_exec.sct s9070_build.bat
